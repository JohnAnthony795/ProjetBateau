# Keil uVision project girouette.uvproj, settings and files
target Simulation (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TP_GPIO
  AfterMake: "C:\Program Files (x86)\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe" release\*.elf
  group pilotes
    ../../pilotes/gpio/: gpio.c gpio.h
    ../../pilotes/timer/: Timer_1234.c Timer_1234.h
    ../../pilotes/clock/: clock.c clock.h
    ../../pilotes/it/: it.c it.h
  group src
    ./src/: main.c
  group Boot
    C:/Keil/stm32lib/stm32f10x/boot/stm32f103/: startup-gcc.S
target Reel (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: TP_GPIO
  AfterMake: as above
